# Autodesk Inventor part: Fig_100-PF-22MM
## iProperties
Created: 2012-01
Part Number: Fig_100-PF-22MM
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
